# Keil uVision project at32f402rct7_demo.uvprojx, settings and files
target template (6210000::V6.21::ARMCLANG)
  device: AT32F402RCT7-7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.1.3
  cpu: IRAM(0x20000000,0x19800) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32f402rct7_demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F402RCT7,USE_STDPERIPH_DRIVER,AT_START_F402_V1
  c include: .\bsp;.\cmsis;.\fireware;.\user\inc;.\user\src;.\libraries\cmsis\cm4\core_support;.\libraries\cmsis\cm4\core_support\dsp;.\libraries\cmsis\dsp\ComputeLibrary\Include;.\libraries\cmsis\dsp\ComputeLibrary\Source;.\fireware\inc;.\fireware\src
  asm include: .\bsp;.\cmsis;.\fireware;.\libraries\drivers\inc;.\libraries\drivers\src;.\user\inc;.\user\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
  group cmsis
    ./cmsis/: system_at32f402_405.c startup_at32f402_405.s
  group fireware
    ./fireware/src/: at32f402_405_acc.c at32f402_405_adc.c at32f402_405_can.c at32f402_405_crc.c at32f402_405_crm.c at32f402_405_debug.c at32f402_405_dma.c at32f402_405_ertc.c at32f402_405_exint.c at32f402_405_flash.c at32f402_405_gpio.c at32f402_405_i2c.c at32f402_405_misc.c at32f402_405_pwc.c at32f402_405_qspi.c at32f402_405_scfg.c at32f402_405_spi.c at32f402_405_tmr.c at32f402_405_usart.c at32f402_405_usb.c at32f402_405_wdt.c at32f402_405_wwdt.c
  group user
    ./user/src/: at32f402_405_clock.c at32f402_405_int.c main.c
    ./user/inc/: at32f402_405_conf.h
  group bsp
    ./bsp/: at32f402_405_board.c
  group readme
    ./readme/: Readme.md
